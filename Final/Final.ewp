# IAR project Final.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarmPART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../FinalProject/: CDD_IOA.c Common_Macros.h Compiler.h Dio.c Dio.h Dio_Cfg.h Dio_LCfg.c Dio_LCfg.h Dio_Regs.h Dio_Types.h Platform_Types.h Port.c Port.h Port_Cfg.h Port_LCfg.c Port_LCfg.h Port_Regs.h Port_Types.h Rte.c Rte.h Rte_CDD_IOA.h Rte_State_Machine.h Rte_State_Manager.h Rte_Type.h startup_ewarm.c State_Machine.c State_Manager.c Std_Types.h Systick.c SysTick.h tm4c123gh6pm.h types.h
    ./: main.c
